# Keil uVision project bootloader.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: AT32F426KBU7-4 ArteryTek
  pack: ArteryTek.AT32F422_426_DFP.2.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader
  AfterMake: fromelf --bin --output="$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: BOOT_JUMP_METHOD = 1
  c include: ..\libraries\cmsis\core_support;..\libraries\cmsis\device_support;..\libraries\drivers\inc;..\mdk_app\Inc;..\mdk_can\Inc;..\mdk_user\Inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group mdk_can
    ../mdk_can/Src/: can_driver.c
  group mdk_libraries
    ../libraries/drivers/src/: at32f422_426_can.c at32f422_426_crm.c at32f422_426_flash.c at32f422_426_gpio.c at32f422_426_misc.c at32f422_426_scfg.c at32f422_426_spi.c
  group mdk_user
    ../libraries/cmsis/device_support/: system_at32f422_426.c
    ../mdk_user/Src/: at32f422_426_clock.c at32f422_426_int.c main.c
  group mdk_app
    ../mdk_app/Src/: boot_jump.c boot_metadata.c boot_safe_mode.c boot_trial.c boot_verify.c sha256.c timer_drv.c uECC.c isotp.c sit1145.c
  group startup
    ../libraries/cmsis/device_support/startup/: startup_at32f422_426.s
